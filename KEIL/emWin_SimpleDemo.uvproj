# Keil uVision project emWin_SimpleDemo.uvproj, settings and files
target emWin_SimpleDemo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: emWin_SimpleDemo
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\tslib;..\..\..\..\Library\CMSIS\Include;..\Thermostat;..\Application\Source\Generated;..\..\..\..\ThirdParty\FatFs\source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
--diag_suppress=L6329
  group Libraries
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
    ../../../../Library/StdDriver/src/: clk.c eadc.c ebi.c gpio.c retarget.c sdh.c sys.c timer.c uart.c fmc.c i2c.c
  group emWin
    ../../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c LCDConf.c
    ../../../../ThirdParty/emWin/Lib/: NUemWin_CM4_Keil.lib
  group Application
    ../Application/Resource/Image/: DARK_Button_Down_100x30.c DARK_Button_Up_100x30.c IndicatorActual_18x2.c IndicatorTarget_24x3.c Leaf_30x39.c Scale_240x240.c fan_40x40.c
    ../Application/Resource/Text/: APPW_Language_0.c
    ../Application/Source/: APPW_MainTask.c
    ../Application/Source/CustomCode/: Application.c ID_SCREEN_00_Slots.c Bitmaps.c
    ../Application/Source/Generated/: APPWConf.c ID_SCREEN_00.c Resource.c
    ../Application/Resource/Font/: NettoOT_16_Normal_EXT_AA4.c NettoOT_32_Normal_EXT_AA4.c Roboto_16_Normal_EXT_AA4.c Roboto_40_Normal_EXT_AA4.c Roboto_150_Normal_EXT_AA4.c
  group tslib
    ../tslib/: ts_calibrate.c M48XTouchPanel.c SDGlue.c diskio.c
  group FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c
  group src
    ../: main.c GUIConf.c
  group thermostat
    ../Thermostat/: thermostat.c platform.c
target emWin_SimpleDemo_SD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: as above
  output: emWin_SimpleDemo_SD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __USE_SD__
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\tslib;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: as above
